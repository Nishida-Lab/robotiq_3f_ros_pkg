Commit message: 座標修正

File: robotiq_3f_gazebo/robots/robotiq_3f_gripper.urdf.gazebo.xacro (robot description, xacro)
@@ -7,4 +7,5 @@
     <parent link="world"/>
     <child link="palm"/>
+    <origin xyz="0 0 0.054" rpy="1.57 0 0"/>
   </joint>
 </robot>
